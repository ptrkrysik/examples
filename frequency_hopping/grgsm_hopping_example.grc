<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.9'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>grgsm_hopping_example</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>generate_options</key><value>no_gui</value></param>
<param><key>run_options</key><value>run</value></param>
</block>
<block>
<key>blocks_file_source</key>
<param><key>id</key><value>blocks_file_source_0</value></param>
<param><key>file</key><value>./recording9_hopping_downlink_941M_samp_12.5M_20160226/out_51.cfile</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>repeat</key><value>False</value></param>
</block>
<block>
<key>blocks_file_source</key>
<param><key>id</key><value>blocks_file_source_0_0</value></param>
<param><key>file</key><value>./recording9_hopping_downlink_941M_samp_12.5M_20160226/out_45.cfile</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>repeat</key><value>False</value></param>
</block>
<block>
<key>blocks_file_source</key>
<param><key>id</key><value>blocks_file_source_0_1</value></param>
<param><key>file</key><value>./recording9_hopping_downlink_941M_samp_12.5M_20160226/out_37.cfile</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>repeat</key><value>False</value></param>
</block>
<block>
<key>blocks_file_source</key>
<param><key>id</key><value>blocks_file_source_0_2</value></param>
<param><key>file</key><value>./recording9_hopping_downlink_941M_samp_12.5M_20160226/out_2.cfile</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>repeat</key><value>False</value></param>
</block>
<block>
<key>blocks_socket_pdu</key>
<param><key>id</key><value>blocks_socket_pdu_0</value></param>
<param><key>host</key><value>127.0.0.1</value></param>
<param><key>mtu</key><value>10000</value></param>
<param><key>port</key><value>4729</value></param>
<param><key>tcp_no_delay</key><value>False</value></param>
<param><key>type</key><value>"UDP_CLIENT"</value></param>
</block>
<block>
<key>blocks_socket_pdu</key>
<param><key>id</key><value>blocks_socket_pdu_0_0</value></param>
<param><key>host</key><value>127.0.0.1</value></param>
<param><key>mtu</key><value>10000</value></param>
<param><key>port</key><value>4729</value></param>
<param><key>tcp_no_delay</key><value>False</value></param>
<param><key>type</key><value>"UDP_SERVER"</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>fc</value></param>
<param><key>label</key><value>fc</value></param>
<param><key>short_id</key><value>f</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>940e6</value></param>
</block>
<block>
<key>gsm_bcch_ccch_demapper</key>
<param><key>id</key><value>gsm_bcch_ccch_demapper_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>timeslot_nr</key><value>0</value></param>
</block>
<block>
<key>gsm_clock_offset_control</key>
<param><key>id</key><value>gsm_clock_offset_control_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>osr</key><value>osr</value></param>
<param><key>fc</key><value>fc</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
</block>
<block>
<key>gsm_control_channels_decoder</key>
<param><key>id</key><value>gsm_control_channels_decoder_0</value></param>
<param><key>_enabled</key><value>0</value></param>
</block>
<block>
<key>gsm_control_channels_decoder</key>
<param><key>id</key><value>gsm_control_channels_decoder_0_0_0_0_0</value></param>
</block>
<block>
<key>gsm_control_channels_decoder</key>
<param><key>id</key><value>gsm_control_channels_decoder_0_0_0_0_0_0</value></param>
</block>
<block>
<key>gsm_control_channels_decoder</key>
<param><key>id</key><value>gsm_control_channels_decoder_0_0_0_0_0_1</value></param>
<param><key>_enabled</key><value>0</value></param>
</block>
<block>
<key>gsm_cx_channel_hopper</key>
<param><key>id</key><value>gsm_cx_channel_hopper_0</value></param>
<param><key>hsn</key><value>0</value></param>
<param><key>ma</key><value>[2,37,45]</value></param>
<param><key>maio</key><value>0</value></param>
</block>
<block>
<key>gsm_cx_channel_hopper</key>
<param><key>id</key><value>gsm_cx_channel_hopper_0_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>hsn</key><value>0</value></param>
<param><key>ma</key><value>[2,37,45]</value></param>
<param><key>maio</key><value>1</value></param>
</block>
<block>
<key>gsm_decryption</key>
<param><key>id</key><value>gsm_decryption_0</value></param>
<param><key>a5_version</key><value>1</value></param>
<param><key>k_c</key><value>[0x75, 0x5c, 0x62, 0x2a, 0x56, 0x15, 0xcf, 0x37]</value></param>
</block>
<block>
<key>gsm_decryption</key>
<param><key>id</key><value>gsm_decryption_0_0</value></param>
<param><key>a5_version</key><value>1</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>k_c</key><value>[0x75, 0x5c, 0x62, 0x2a, 0x56, 0x15, 0xcf, 0x37]</value></param>
</block>
<block>
<key>gsm_decryption</key>
<param><key>id</key><value>gsm_decryption_0_0_0</value></param>
<param><key>a5_version</key><value>1</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>k_c</key><value>[0x75, 0x5c, 0x62, 0x2a, 0x56, 0x15, 0xcf, 0x37]</value></param>
</block>
<block>
<key>gsm_input</key>
<param><key>id</key><value>gsm_input_0</value></param>
<param><key>samp_rate_in</key><value>samp_rate</value></param>
</block>
<block>
<key>gsm_input</key>
<param><key>id</key><value>gsm_input_0_0</value></param>
<param><key>samp_rate_in</key><value>samp_rate</value></param>
</block>
<block>
<key>gsm_input</key>
<param><key>id</key><value>gsm_input_0_0_0</value></param>
<param><key>samp_rate_in</key><value>samp_rate</value></param>
</block>
<block>
<key>gsm_input</key>
<param><key>id</key><value>gsm_input_0_0_0_0</value></param>
<param><key>samp_rate_in</key><value>samp_rate</value></param>
</block>
<block>
<key>gsm_message_printer</key>
<param><key>id</key><value>gsm_message_printer_0</value></param>
<param><key>prepend_frame_count</key><value>False</value></param>
<param><key>prepend_fnr</key><value>False</value></param>
<param><key>prepend_string</key><value>""</value></param>
<param><key>print_gsmtap_header</key><value>False</value></param>
</block>
<block>
<key>gsm_receiver</key>
<param><key>id</key><value>gsm_receiver_0</value></param>
<param><key>cell_allocation</key><value>[51,2,37,45]</value></param>
<param><key>num_streams</key><value>4</value></param>
<param><key>osr</key><value>osr</value></param>
<param><key>tseq_nums</key><value>[4]</value></param>
</block>
<block>
<key>gsm_sdcch8_demapper</key>
<param><key>id</key><value>gsm_sdcch8_demapper_0</value></param>
<param><key>timeslot_nr</key><value>0</value></param>
</block>
<block>
<key>gsm_tch_f_chans_demapper</key>
<param><key>id</key><value>gsm_tch_f_chans_demapper_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>timeslot_nr</key><value>5</value></param>
</block>
<block>
<key>gsm_tch_f_decoder</key>
<param><key>id</key><value>gsm_tch_f_decoder_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>mode</key><value>grgsm.TCH_FS</value></param>
<param><key>boundary_check</key><value>True</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>osr</value></param>
<param><key>label</key><value>OSR</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>4</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>ppm</value></param>
<param><key>label</key><value>clock_correction</value></param>
<param><key>short_id</key><value>p</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>-0.5</value></param>
</block>
<block>
<key>qtgui_sink_x</key>
<param><key>id</key><value>qtgui_sink_x_0</value></param>
<param><key>bw</key><value>samp_rate</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>freqchangevar</key><value>None</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>label</key><value>samp_rate</value></param>
<param><key>short_id</key><value>s</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>0.5e6</value></param>
</block>
<connection><source_block_id>blocks_file_source_0</source_block_id><sink_block_id>gsm_input_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_file_source_0</source_block_id><sink_block_id>qtgui_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_file_source_0_0</source_block_id><sink_block_id>gsm_input_0_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_file_source_0_1</source_block_id><sink_block_id>gsm_input_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_file_source_0_2</source_block_id><sink_block_id>gsm_input_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gsm_bcch_ccch_demapper_0</source_block_id><sink_block_id>gsm_control_channels_decoder_0</sink_block_id><source_key>bursts</source_key><sink_key>bursts</sink_key></connection>
<connection><source_block_id>gsm_clock_offset_control_0</source_block_id><sink_block_id>gsm_input_0</sink_block_id><source_key>ctrl</source_key><sink_key>ctrl_in</sink_key></connection>
<connection><source_block_id>gsm_clock_offset_control_0</source_block_id><sink_block_id>gsm_input_0_0</sink_block_id><source_key>ctrl</source_key><sink_key>ctrl_in</sink_key></connection>
<connection><source_block_id>gsm_clock_offset_control_0</source_block_id><sink_block_id>gsm_input_0_0_0</sink_block_id><source_key>ctrl</source_key><sink_key>ctrl_in</sink_key></connection>
<connection><source_block_id>gsm_clock_offset_control_0</source_block_id><sink_block_id>gsm_input_0_0_0_0</sink_block_id><source_key>ctrl</source_key><sink_key>ctrl_in</sink_key></connection>
<connection><source_block_id>gsm_control_channels_decoder_0</source_block_id><sink_block_id>blocks_socket_pdu_0</sink_block_id><source_key>msgs</source_key><sink_key>pdus</sink_key></connection>
<connection><source_block_id>gsm_control_channels_decoder_0_0_0_0_0</source_block_id><sink_block_id>blocks_socket_pdu_0</sink_block_id><source_key>msgs</source_key><sink_key>pdus</sink_key></connection>
<connection><source_block_id>gsm_control_channels_decoder_0_0_0_0_0</source_block_id><sink_block_id>gsm_message_printer_0</sink_block_id><source_key>msgs</source_key><sink_key>msgs</sink_key></connection>
<connection><source_block_id>gsm_control_channels_decoder_0_0_0_0_0_0</source_block_id><sink_block_id>blocks_socket_pdu_0</sink_block_id><source_key>msgs</source_key><sink_key>pdus</sink_key></connection>
<connection><source_block_id>gsm_control_channels_decoder_0_0_0_0_0_0</source_block_id><sink_block_id>gsm_message_printer_0</sink_block_id><source_key>msgs</source_key><sink_key>msgs</sink_key></connection>
<connection><source_block_id>gsm_control_channels_decoder_0_0_0_0_0_1</source_block_id><sink_block_id>blocks_socket_pdu_0</sink_block_id><source_key>msgs</source_key><sink_key>pdus</sink_key></connection>
<connection><source_block_id>gsm_control_channels_decoder_0_0_0_0_0_1</source_block_id><sink_block_id>gsm_message_printer_0</sink_block_id><source_key>msgs</source_key><sink_key>msgs</sink_key></connection>
<connection><source_block_id>gsm_cx_channel_hopper_0</source_block_id><sink_block_id>gsm_sdcch8_demapper_0</sink_block_id><source_key>bursts</source_key><sink_key>bursts</sink_key></connection>
<connection><source_block_id>gsm_cx_channel_hopper_0_0</source_block_id><sink_block_id>gsm_tch_f_chans_demapper_0</sink_block_id><source_key>bursts</source_key><sink_key>bursts</sink_key></connection>
<connection><source_block_id>gsm_decryption_0</source_block_id><sink_block_id>gsm_control_channels_decoder_0_0_0_0_0</sink_block_id><source_key>bursts</source_key><sink_key>bursts</sink_key></connection>
<connection><source_block_id>gsm_decryption_0_0</source_block_id><sink_block_id>gsm_control_channels_decoder_0_0_0_0_0_1</sink_block_id><source_key>bursts</source_key><sink_key>bursts</sink_key></connection>
<connection><source_block_id>gsm_decryption_0_0_0</source_block_id><sink_block_id>gsm_tch_f_decoder_0</sink_block_id><source_key>bursts</source_key><sink_key>bursts</sink_key></connection>
<connection><source_block_id>gsm_input_0</source_block_id><sink_block_id>gsm_receiver_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gsm_input_0_0</source_block_id><sink_block_id>gsm_receiver_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>gsm_input_0_0_0</source_block_id><sink_block_id>gsm_receiver_0</sink_block_id><source_key>0</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>gsm_input_0_0_0_0</source_block_id><sink_block_id>gsm_receiver_0</sink_block_id><source_key>0</source_key><sink_key>3</sink_key></connection>
<connection><source_block_id>gsm_receiver_0</source_block_id><sink_block_id>gsm_bcch_ccch_demapper_0</sink_block_id><source_key>C0</source_key><sink_key>bursts</sink_key></connection>
<connection><source_block_id>gsm_receiver_0</source_block_id><sink_block_id>gsm_cx_channel_hopper_0</sink_block_id><source_key>CX</source_key><sink_key>CX</sink_key></connection>
<connection><source_block_id>gsm_receiver_0</source_block_id><sink_block_id>gsm_cx_channel_hopper_0_0</sink_block_id><source_key>CX</source_key><sink_key>CX</sink_key></connection>
<connection><source_block_id>gsm_receiver_0</source_block_id><sink_block_id>gsm_clock_offset_control_0</sink_block_id><source_key>measurements</source_key><sink_key>measurements</sink_key></connection>
<connection><source_block_id>gsm_sdcch8_demapper_0</source_block_id><sink_block_id>gsm_control_channels_decoder_0_0_0_0_0_0</sink_block_id><source_key>bursts</source_key><sink_key>bursts</sink_key></connection>
<connection><source_block_id>gsm_sdcch8_demapper_0</source_block_id><sink_block_id>gsm_decryption_0</sink_block_id><source_key>bursts</source_key><sink_key>bursts</sink_key></connection>
<connection><source_block_id>gsm_tch_f_chans_demapper_0</source_block_id><sink_block_id>gsm_decryption_0_0</sink_block_id><source_key>acch_bursts</source_key><sink_key>bursts</sink_key></connection>
<connection><source_block_id>gsm_tch_f_chans_demapper_0</source_block_id><sink_block_id>gsm_decryption_0_0_0</sink_block_id><source_key>tch_bursts</source_key><sink_key>bursts</sink_key></connection>
<connection><source_block_id>gsm_tch_f_decoder_0</source_block_id><sink_block_id>blocks_socket_pdu_0</sink_block_id><source_key>msgs</source_key><sink_key>pdus</sink_key></connection>
<connection><source_block_id>gsm_tch_f_decoder_0</source_block_id><sink_block_id>gsm_message_printer_0</sink_block_id><source_key>msgs</source_key><sink_key>msgs</sink_key></connection>
</flow_graph>
