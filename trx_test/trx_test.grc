<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.9'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>trx_test</value></param>
<param><key>author</key><value>(C) Piotr Krysik 2017</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
<param><key>run_options</key><value>run</value></param>
<param><key>title</key><value>Test of RX and TX integration</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>fc_downlink_slider</value></param>
<param><key>value</key><value>fc_downlink</value></param>
<param><key>label</key><value>fc_downlink_slider</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>100e3</value></param>
<param><key>stop</key><value>10e9</value></param>
</block>
<block>
<key>epy_block</key>
<param><key>id</key><value>add_const_to_frame_number</value></param>
<param><key>_source_code</key><value>"""
Embedded Python Blocks:

Each this file is saved, GRC will instantiate the first class it finds to get
ports and parameters of your block. The arguments to __init__  will be the
parameters. All of them are required to have default values!
"""
import numpy as np
from gnuradio import gr
import pmt

class add_const_to_frame_number(gr.sync_block):
    def __init__(self, const_num=0):
        gr.sync_block.__init__(
            self,
            name='Add const to frame number',
            in_sig=[],
            out_sig=[]
        )
        self.const_num = int(const_num)
        self.message_port_register_in(pmt.intern("bursts_in"))
        self.message_port_register_out(pmt.intern("bursts_out"))
        self.set_msg_handler(pmt.intern("bursts_in"), self.add_const_to_fn)

    def add_const_to_fn(self, msg):
        burst_with_header = pmt.to_python(pmt.cdr(msg))
        fn = burst_with_header[11]+burst_with_header[10]*2**8+burst_with_header[9]*2**16+burst_with_header[8]*2**24
        
#        print burst_with_header[11],burst_with_header[10],burst_with_header[9],burst_with_header[11]
        fn_new = (fn+self.const_num) % (26*51*2048)
        burst_with_header[11] = fn_new &amp; 0xff
        burst_with_header[10] = (fn_new &gt;&gt; 8) &amp; 0xff
        burst_with_header[9] = (fn_new &gt;&gt; 2*8) &amp; 0xff
        burst_with_header[8] = (fn_new &gt;&gt; 3*8) &amp; 0xff
        
        msg_new = pmt.cons(pmt.car(msg), pmt.to_pmt(burst_with_header))
        self.message_port_pub(pmt.intern("bursts_out"), msg_new)
</value></param>
<param><key>const_num</key><value>200</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>file</key><value>/home/piotr/GRGSM_TRX/integracja_tx_rx/dane_synchro/synchro_test6</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_message_debug</key>
<param><key>id</key><value>blocks_message_debug_0</value></param>
<param><key>_enabled</key><value>0</value></param>
</block>
<block>
<key>blocks_pdu_to_tagged_stream</key>
<param><key>id</key><value>blocks_pdu_to_tagged_stream_0_0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>tag</key><value>packet_len</value></param>
</block>
<block>
<key>blocks_tag_debug</key>
<param><key>id</key><value>blocks_tag_debug_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>filter</key><value>"tx_time"</value></param>
</block>
<block>
<key>epy_block</key>
<param><key>id</key><value>burst_to_fn_time_0_0</value></param>
<param><key>_source_code</key><value>"""
Embedded Python Blocks:

Each this file is saved, GRC will instantiate the first class it finds to get
ports and parameters of your block. The arguments to __init__  will be the
parameters. All of them are required to have default values!
"""

from gnuradio import gr
from pmt import *

class change_sign_of_dict_elements(gr.basic_block):
    def __init__(self):  # only default arguments here
        gr.basic_block.__init__(
            self,
            name='Change sign of elts in dict',
            in_sig=[],
            out_sig=[]
        )
        self.message_port_register_in(intern("dict_in"))
        self.message_port_register_out(intern("dict_out"))
        self.set_msg_handler(intern("dict_in"), self.change_sign)

    def change_sign(self, msg):
        if is_dict(msg):
            d = to_python(msg)
            print d
            for key, value in d.items():
                d[key] *= -1
            self.message_port_pub(intern("dict_out"), to_pmt(d))
</value></param>
<param><key>_enabled</key><value>0</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>delay_correction</value></param>
<param><key>label</key><value>delay_correction</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>285.616e-6</value></param>
</block>
<block>
<key>digital_burst_shaper_xx</key>
<param><key>id</key><value>digital_burst_shaper_xx_0</value></param>
<param><key>insert_phasing</key><value>False</value></param>
<param><key>length_tag_name</key><value>"packet_len"</value></param>
<param><key>post_padding</key><value>20</value></param>
<param><key>pre_padding</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>window</key><value>firdes.window(firdes.WIN_HANN, 16, 0)</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>fc_downlink</value></param>
<param><key>label</key><value>fc_downlink</value></param>
<param><key>short_id</key><value>d</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>938600000</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>fc_uplink</value></param>
<param><key>label</key><value>fc_uplink</value></param>
<param><key>short_id</key><value>u</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>938900000</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>gain_downlink</value></param>
<param><key>label</key><value>gain_downlink</value></param>
<param><key>short_id</key><value>g</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>40</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>gain_uplink</value></param>
<param><key>label</key><value>gain_uplink</value></param>
<param><key>short_id</key><value>r</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>60</value></param>
</block>
<block>
<key>gsm_bcch_ccch_demapper</key>
<param><key>id</key><value>gsm_bcch_ccch_demapper_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>timeslot_nr</key><value>0</value></param>
</block>
<block>
<key>gsm_burst_to_fn_time</key>
<param><key>id</key><value>gsm_burst_to_fn_time_0</value></param>
</block>
<block>
<key>gsm_burst_type_filter</key>
<param><key>id</key><value>gsm_burst_type_filter_0</value></param>
<param><key>selected_burst_types</key><value>[3]</value></param>
</block>
<block>
<key>gsm_clock_offset_control</key>
<param><key>id</key><value>gsm_clock_offset_control_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>osr</key><value>osr</value></param>
<param><key>fc</key><value>fc_downlink</value></param>
<param><key>samp_rate</key><value>samp_rate_downlink</value></param>
</block>
<block>
<key>gsm_control_channels_decoder</key>
<param><key>id</key><value>gsm_control_channels_decoder_0</value></param>
<param><key>_enabled</key><value>0</value></param>
</block>
<block>
<key>gsm_controlled_rotator_cc</key>
<param><key>id</key><value>gsm_controlled_rotator_cc_0</value></param>
<param><key>phase_inc</key><value>ppm/1.0e6*2*math.pi*fc_downlink/samp_rate</value></param>
</block>
<block>
<key>gsm_controlled_rotator_cc</key>
<param><key>id</key><value>gsm_controlled_rotator_cc_0_0</value></param>
<param><key>phase_inc</key><value>-ppm/1.0e6*2*math.pi*fc_downlink/samp_rate</value></param>
</block>
<block>
<key>gsm_gmsk_mod</key>
<param><key>id</key><value>gsm_gmsk_mod_0</value></param>
<param><key>BT</key><value>0.3</value></param>
<param><key>pulse_duration</key><value>4</value></param>
<param><key>sps</key><value>osr</value></param>
</block>
<block>
<key>gsm_message_printer</key>
<param><key>id</key><value>gsm_message_printer_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>prepend_frame_count</key><value>False</value></param>
<param><key>prepend_fnr</key><value>False</value></param>
<param><key>print_gsmtap_header</key><value>False</value></param>
</block>
<block>
<key>gsm_msg_to_tag</key>
<param><key>id</key><value>gsm_msg_to_tag_0</value></param>
</block>
<block>
<key>gsm_msg_to_tag</key>
<param><key>id</key><value>gsm_msg_to_tag_0_0</value></param>
</block>
<block>
<key>gsm_preprocess_tx_burst</key>
<param><key>id</key><value>gsm_preprocess_tx_burst_0</value></param>
</block>
<block>
<key>gsm_receiver</key>
<param><key>id</key><value>gsm_receiver_0</value></param>
<param><key>osr</key><value>4</value></param>
<param><key>tseq_nums</key><value>[4]</value></param>
</block>
<block>
<key>gsm_txtime_setter</key>
<param><key>id</key><value>gsm_txtime_setter_0</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0</value></param>
<param><key>import</key><value>import math</value></param>
</block>
<block>
<key>low_pass_filter</key>
<param><key>id</key><value>low_pass_filter_0_0</value></param>
<param><key>cutoff_freq</key><value>125e3</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>type</key><value>fir_filter_ccf</value></param>
<param><key>gain</key><value>1</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>width</key><value>5e3</value></param>
<param><key>win</key><value>firdes.WIN_HAMMING</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>osr</value></param>
<param><key>label</key><value>OSR</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>4</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>ppm</value></param>
<param><key>label</key><value>Clock offset correction</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>-1</value></param>
</block>
<block>
<key>qtgui_freq_sink_x</key>
<param><key>id</key><value>qtgui_freq_sink_x_0</value></param>
<param><key>bw</key><value>samp_rate</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>label</key><value>samp_rate</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>13.0e6/12.0</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>samp_rate_downlink</value></param>
<param><key>label</key><value>samp_rate_downlink</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>13.0e6/12.0</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>timing_advance</value></param>
<param><key>label</key><value>timing_advance</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>uhd_usrp_sink</key>
<param><key>id</key><value>uhd_usrp_sink_0</value></param>
<param><key>ant0</key><value>TX/RX</value></param>
<param><key>center_freq0</key><value>fc_uplink</value></param>
<param><key>norm_gain0</key><value>False</value></param>
<param><key>gain0</key><value>gain_uplink</value></param>
<param><key>clock_rate</key><value>26e6</value></param>
<param><key>dev_args</key><value>""</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>sd_spec0</key><value>A:B</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>hide_cmd_port</key><value>False</value></param>
<param><key>hide_lo_controls</key><value>True</value></param>
<param><key>sync</key><value></value></param>
<param><key>len_tag_name</key><value>"packet_len"</value></param>
</block>
<block>
<key>uhd_usrp_source</key>
<param><key>id</key><value>uhd_usrp_source_0</value></param>
<param><key>ant0</key><value>RX2</value></param>
<param><key>center_freq0</key><value>fc_downlink_slider</value></param>
<param><key>dc_offs_enb0</key><value>""</value></param>
<param><key>iq_imbal_enb0</key><value>""</value></param>
<param><key>norm_gain0</key><value>False</value></param>
<param><key>gain0</key><value>gain_downlink</value></param>
<param><key>clock_rate</key><value>26e6</value></param>
<param><key>dev_args</key><value>""</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>hide_cmd_port</key><value>False</value></param>
<param><key>hide_lo_controls</key><value>True</value></param>
<param><key>sync</key><value></value></param>
</block>
<connection><source_block_id>add_const_to_frame_number</source_block_id><sink_block_id>gsm_txtime_setter_0</sink_block_id><source_key>bursts_out</source_key><sink_key>bursts_in</sink_key></connection>
<connection><source_block_id>blocks_pdu_to_tagged_stream_0_0</source_block_id><sink_block_id>gsm_gmsk_mod_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>burst_to_fn_time_0_0</source_block_id><sink_block_id>gsm_msg_to_tag_0_0</sink_block_id><source_key>dict_out</source_key><sink_key>msg</sink_key></connection>
<connection><source_block_id>digital_burst_shaper_xx_0</source_block_id><sink_block_id>gsm_msg_to_tag_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gsm_bcch_ccch_demapper_0</source_block_id><sink_block_id>gsm_control_channels_decoder_0</sink_block_id><source_key>bursts</source_key><sink_key>bursts</sink_key></connection>
<connection><source_block_id>gsm_burst_to_fn_time_0</source_block_id><sink_block_id>blocks_message_debug_0</sink_block_id><source_key>fn_time_out</source_key><sink_key>print</sink_key></connection>
<connection><source_block_id>gsm_burst_to_fn_time_0</source_block_id><sink_block_id>gsm_txtime_setter_0</sink_block_id><source_key>fn_time_out</source_key><sink_key>fn_time</sink_key></connection>
<connection><source_block_id>gsm_burst_type_filter_0</source_block_id><sink_block_id>gsm_burst_to_fn_time_0</sink_block_id><source_key>bursts_out</source_key><sink_key>bursts_in</sink_key></connection>
<connection><source_block_id>gsm_clock_offset_control_0</source_block_id><sink_block_id>burst_to_fn_time_0_0</sink_block_id><source_key>ctrl</source_key><sink_key>dict_in</sink_key></connection>
<connection><source_block_id>gsm_clock_offset_control_0</source_block_id><sink_block_id>gsm_msg_to_tag_0</sink_block_id><source_key>ctrl</source_key><sink_key>msg</sink_key></connection>
<connection><source_block_id>gsm_control_channels_decoder_0</source_block_id><sink_block_id>gsm_message_printer_0</sink_block_id><source_key>msgs</source_key><sink_key>msgs</sink_key></connection>
<connection><source_block_id>gsm_controlled_rotator_cc_0</source_block_id><sink_block_id>low_pass_filter_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gsm_controlled_rotator_cc_0_0</source_block_id><sink_block_id>blocks_tag_debug_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gsm_controlled_rotator_cc_0_0</source_block_id><sink_block_id>uhd_usrp_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gsm_gmsk_mod_0</source_block_id><sink_block_id>digital_burst_shaper_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gsm_msg_to_tag_0</source_block_id><sink_block_id>gsm_controlled_rotator_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gsm_msg_to_tag_0_0</source_block_id><sink_block_id>gsm_controlled_rotator_cc_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gsm_preprocess_tx_burst_0</source_block_id><sink_block_id>blocks_pdu_to_tagged_stream_0_0</sink_block_id><source_key>bursts_out</source_key><sink_key>pdus</sink_key></connection>
<connection><source_block_id>gsm_receiver_0</source_block_id><sink_block_id>add_const_to_frame_number</sink_block_id><source_key>C0</source_key><sink_key>bursts_in</sink_key></connection>
<connection><source_block_id>gsm_receiver_0</source_block_id><sink_block_id>gsm_bcch_ccch_demapper_0</sink_block_id><source_key>C0</source_key><sink_key>bursts</sink_key></connection>
<connection><source_block_id>gsm_receiver_0</source_block_id><sink_block_id>gsm_burst_type_filter_0</sink_block_id><source_key>C0</source_key><sink_key>bursts_in</sink_key></connection>
<connection><source_block_id>gsm_receiver_0</source_block_id><sink_block_id>gsm_clock_offset_control_0</sink_block_id><source_key>measurements</source_key><sink_key>measurements</sink_key></connection>
<connection><source_block_id>gsm_txtime_setter_0</source_block_id><sink_block_id>gsm_preprocess_tx_burst_0</sink_block_id><source_key>bursts_out</source_key><sink_key>bursts_in</sink_key></connection>
<connection><source_block_id>low_pass_filter_0_0</source_block_id><sink_block_id>gsm_receiver_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0</source_block_id><sink_block_id>blocks_file_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0</source_block_id><sink_block_id>gsm_msg_to_tag_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0</source_block_id><sink_block_id>qtgui_freq_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
